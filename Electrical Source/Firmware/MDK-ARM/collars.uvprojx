# Keil uVision project collars.uvprojx, settings and files
target AnimalCollar (6120000::V6.12::.\ARMCLANG)
  device: STM32L071KZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: AnimalCollar +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L071xx,STM32L071xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=262144,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc;  ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User
    ../Inc/: comport.h flash.h globals.h gps.h main.h scheduler.h stm32_assert.h stm32l0xx_it.h timers.h xbee.h lowpower.h
    ../Src/: comport.c flash.c gps.c scheduler.c timers.c xbee.c main.c stm32l0xx_it.c lowpower.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_dma.c stm32l0xx_ll_pwr.c stm32l0xx_ll_exti.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c
software components: CMSIS:CORE 5.2.0
